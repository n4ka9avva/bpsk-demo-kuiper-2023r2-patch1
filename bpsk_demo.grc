options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_8_cusom
    output_language: python
    qt_qss_theme: C:/Users/yutan/radioconda/Library/share/gnuradio/themes/plain.qss
    title: pkt_8_custom
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: access_key
  id: variable
  parameters:
    value: '''1110101110010000'''
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: 2,2,1,1
    gui_hint: 2,2,1,1
    label: Costas Loop BW
    min_len: '50'
    start: '0'
    step: '0.002'
    stop: '0.1'
    value: '0.06'
  states: {}
- name: fll_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: 2,1,1,1
    gui_hint: 2,1,1,1
    label: FLL Base-Edge Loop BW
    min_len: '50'
    start: '0.0'
    step: '0.002'
    stop: '0.1'
    value: '0.06'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: 'tab_id@1 : 0,2,1,1'
    gui_hint: 'tab_id@1 : 0,2,1,1'
    label: Frequency Offset
    min_len: '50'
    start: '-0.05'
    step: '0.001'
    stop: '0.05'
    value: '0.004'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: lo
  id: variable
  parameters:
    value: int(2.4e9)
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4
    gain: '1'
    samp_rate: samp_rate
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: lpf_taps_upsampling
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: baud_rate * (1.0 + Alpha) / 2.0
    gain: upsampling*0.9
    samp_rate: samp_rate
    width: baud_rate * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: msg
  id: variable
  parameters:
    comment: 16 bytes
    value: b"Hello, GnuRadio! Can you hear me?"
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: 'tab_id@1 : 0,0,1,1'
    gui_hint: 'tab_id@1 : 0,0,1,1'
    label: 'Channel: Noise Voltage'
    min_len: '50'
    start: '0'
    step: '0.02'
    stop: '1'
    value: '0.1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: Alpha
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: baud_rate
    sym_rate: baud_rate
  states: {state: disabled}
- name: rx_gain
  id: variable_qtgui_dial_control
  parameters:
    comment: 2,0,1,1
    gui_hint: 2,0,1,1
    label: Rx Gain
    maximum: '70'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps*upsampling
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sync_loop_bw
  id: variable_qtgui_range
  parameters:
    comment: 2,3,1,1
    gui_hint: 2,3,1,1
    label: Symbol Sync Loop BW
    min_len: '100'
    start: '0.0'
    step: '0.001'
    stop: '0.01'
    value: '0.005'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    comment: 'tab_id@1 : 0,1,1,1'
    gui_hint: 'tab_id@1 : 0,1,1,1'
    label: Timing Offset
    min_len: '100'
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0005'
    widget: counter
  states: {}
- name: tx_atten
  id: variable_qtgui_dial_control
  parameters:
    comment: 'tab_id@0 : 1,0,1,1'
    gui_hint: 'tab_id@0 : 1,0,1,1'
    label: Tx Attenuation
    maximum: '60'
    minimum: '0'
    showvalue: 'True'
    type: int
    value: '60'
  states: {}
- name: tx_lo_offset
  id: variable_qtgui_range
  parameters:
    comment: 'tab_id@0 : 1,1,1,3'
    gui_hint: 'tab_id@0 : 1,1,1,3'
    label: Tx Lo Offset
    start: '-1000e3'
    step: 1e3
    stop: 1000e3
    value: '0'
  states: {}
- name: upsampling
  id: variable
  parameters:
    value: '50'
  states: {}
- name: use_hw
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: Hardware Enable/Disable
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    comment: 'tab_id@1 : 0,3,1,1'
    formatter: 'lambda x: f"CFO: {x:.3f} [kHz]"'
    gui_hint: 'tab_id@1 : 0,3,1,1'
    label: Freq Offset [kHz}
    type: real
    value: samp_rate*freq_offset/1e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(len(msg),list(msg)))
    period: '3000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: int(use_hw)
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: int(use_hw)
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame_seq"'
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"frame_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate / 10
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: 1+0j
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    comment: BPSK modulation
    constellation: const
    differential: 'True'
    excess_bw: Alpha
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop_bw
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    comment: +CRC (2 bytes)
    final_xor: '0xFFFF'
    initial_value: '0xFFFF'
    num_bits: '16'
    poly: '0x1021'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    num_bits: '16'
    poly: '0x1021'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_protocol_formatter_async
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_loop_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo
    decim: upsampling
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: int(samp_rate / 2)
    bbdc: 'True'
    buffer_size: int(256e3)
    comment: Real Receiver
    filter: C:\Users\yutan\WorkSpace\ADALM-PLUTO-Examples\designed filter\lpf_EPB-7.5kSSB-62k.txt
    filter_source: '''Auto'''
    frequency: 'lo '
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:analog.local
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: int(samp_rate/2)
    buffer_size: int(128e3)
    comment: Real Transceiver
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: lo + int(tx_lo_offset)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: parse_telecmd
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """CCSDS Telecommand Deframer (PDU)"""

          def __init__(self):
              gr.basic_block.__init__(self,
                  name="CCSDS Telecommand Deframer (PDU)",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = bytes(pmt.u8vector_elements(pmt.cdr(pdu)))

              if len(data) < 6:
                  return  # 不正フレーム（ヘッダ不足）

              # Primary Header除去
              header = data[:5]
              payload = data[5:]

              # Parse header
              frame_len = int.from_bytes(header[2:4], 'big') & 0x3FF # LSB 10bit
              frame_seq = header[4] 

              # meta情報にAPIDなどを追加（任意）
              meta = pmt.dict_add(meta, pmt.intern("frame_len"), pmt.from_long(frame_len))
              meta = pmt.dict_add(meta, pmt.intern("frame_seq"), pmt.from_long(frame_seq))

              out_pdu = pmt.cons(meta, pmt.init_u8vector(len(payload), list(payload)))
              self.message_port_pub(pmt.intern('pdu_out'), out_pdu)
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Header
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: Payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 3,3,1,1
    gui_hint: 3,3,1,1
    label1: BPSK
    name: ''
    size: '1024'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    comment: 'tab_id@0 : 0,0,1,1'
    gui_hint: 'tab_id@0 : 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    alpha3: '0.5'
    bw: samp_rate
    color2: '"green"'
    color3: '"red"'
    comment: 3,0,1,2
    fc: lo
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: '"Raw rx signal"'
    label2: '"Xlatching FIR Filter"'
    label3: '"FLL Band-Edge"'
    nconnections: '3'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    bw: samp_rate
    comment: 'tab_id@0 : 0,2,1,2'
    fc: lo
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'tab_id@0 : 0,2,1,2'
    label1: '"Only Decimation"'
    label2: '"With LPF"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    alpha3: '0.7'
    alpha4: '0.7'
    autoscale: 'True'
    comment: 'tab_id@0 : 0,1,1,1'
    grid: 'True'
    gui_hint: 'tab_id@0 : 0,1,1,1'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: 3,2,1,1
    grid: 'True'
    gui_hint: 3,2,1,1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: upsampling
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: upsampling
    taps: lpf_taps_upsampling
    type: ccc
  states: {}
- name: satellites_telecommand_primaryheader_adder_0
  id: satellites_telecommand_primaryheader_adder
  parameters:
    bypass: '0'
    comment: +Frame Header (5 bytes)
    control: '0'
    spacecraft_id: '0'
    virtual_channel_id: '0'
  states: {}
- name: tab_id
  id: qtgui_tab_widget
  parameters:
    label0: Transceiver
    label1: Virtual Channel
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ToTransceiver
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: ToEnframe
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: ToChannelModel
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: FromChannelModel
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: decoded
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: ToDecode
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: Xlatch FIR
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: FLL Band-Edge
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    stream_id: Costas Loop
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: Transceiver
    stream_id: ToTransceiver
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: ToEnframe
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: Wireless simulation
    stream_id: ToChannelModel
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    comment: Receiver
    stream_id: FromChannelModel
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: decoded
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    comment: Decode
    stream_id: ToDecode
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: Xlatch FIR
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: FLL Band-Edge
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: Costas Loop
  states: {}
- name: zeromq_pull_msg_source
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52001
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:52002
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52001
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:52002
    timeout: '100'
  states: {}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_message_strobe, strobe, zeromq_push_msg_sink, in]
- [blocks_null_source_0, '0', blocks_selector_2, '1']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_selector_1, '0', virtual_sink_2, '0']
- [blocks_selector_1, '1', blocks_null_sink_0, '0']
- [blocks_selector_1, '1', iio_pluto_sink_0, '0']
- [blocks_selector_2, '0', analog_agc_xx_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', virtual_sink_3, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', rational_resampler_xxx_0, '0']
- [digital_constellation_modulator_0, '0', rational_resampler_xxx_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_8, '0']
- [digital_crc_append_0, out, virtual_sink_1, '0']
- [digital_crc_check_0, fail, blocks_message_debug_0, print]
- [digital_crc_check_0, ok, parse_telecmd, pdu_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_fll_band_edge_cc_0, '0', virtual_sink_7, '0']
- [digital_map_bb_0, '0', virtual_sink_4, '0']
- [digital_protocol_formatter_async, header, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async, payload, pdu_pdu_to_tagged_stream_1, pdus]
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_5, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_fll_band_edge_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_6, '0']
- [iio_fmcomms2_source_0, '0', blocks_selector_2, '1']
- [parse_telecmd, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_tag_debug_1, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, zeromq_push_msg_sink_0, in]
- [rational_resampler_xxx_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_1, '1']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [satellites_telecommand_primaryheader_adder_0, out, digital_crc_append_0, in]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', digital_protocol_formatter_async, in]
- [virtual_source_2, '0', blocks_throttle2_0, '0']
- [virtual_source_3, '0', blocks_selector_2, '0']
- [virtual_source_4, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_5, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_6, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_7, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_8, '0', qtgui_freq_sink_x_0, '2']
- [zeromq_pull_msg_source, out, satellites_telecommand_primaryheader_adder_0, in]
- [zeromq_pull_msg_source_0, out, digital_crc_check_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0

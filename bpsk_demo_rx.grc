options:
  parameters:
    generate_options: no_gui
    id: bpsk_demo_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: costas_loop_bw
  id: variable
  parameters:
    value: '60.0e-3'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '60.0e-3'
  states: {}
- name: lo
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/4
    gain: '1'
    samp_rate: samp_rate
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), Alpha, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps*upsampling
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sync_loop_bw
  id: variable
  parameters:
    value: '5.0e-3'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: upsampling
  id: variable
  parameters:
    value: '50'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '2.0'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame_seq"'
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"frame_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: costas_loop_bw
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    num_bits: '16'
    poly: '0x1021'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: Alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_loop_bw
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo
    decim: upsampling
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: int(samp_rate / 2)
    bbdc: 'True'
    buffer_size: int(256e3)
    comment: Real Receiver
    filter: C:\Users\yutan\WorkSpace\ADALM-PLUTO-Examples\designed filter\lpf_EPB-7.5kSSB-62k.txt
    filter_source: '''Auto'''
    frequency: int(lo)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:127.0.0.1
  states: {}
- name: parse_telecmd
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          """CCSDS Telecommand Deframer (PDU)"""

          def __init__(self):
              gr.basic_block.__init__(self,
                  name="CCSDS Telecommand Deframer (PDU)",
                  in_sig=None,
                  out_sig=None)

              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_pdu)

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = bytes(pmt.u8vector_elements(pmt.cdr(pdu)))

              if len(data) < 6:
                  return  # 不正フレーム（ヘッダ不足）

              # Primary Header除去
              header = data[:5]
              payload = data[5:]

              # Parse header
              frame_len = int.from_bytes(header[2:4], 'big') & 0x3FF # LSB 10bit
              frame_seq = header[4] 

              # meta情報にAPIDなどを追加（任意）
              meta = pmt.dict_add(meta, pmt.intern("frame_len"), pmt.from_long(frame_len))
              meta = pmt.dict_add(meta, pmt.intern("frame_seq"), pmt.from_long(frame_seq))

              out_pdu = pmt.cons(meta, pmt.init_u8vector(len(payload), list(payload)))
              self.message_port_pub(pmt.intern('pdu_out'), out_pdu)
  states: {}
- name: pdu_pdu_to_tagged_stream_2
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ToDecode
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Telecommand
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: decoded
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Telecommand
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: decoded
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    comment: Decode
    stream_id: ToDecode
  states: {}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_crc_check_0, fail, blocks_message_debug_0, print]
- [digital_crc_check_0, ok, parse_telecmd, pdu_in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', virtual_sink_4, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_fll_band_edge_cc_0, '0']
- [iio_fmcomms2_source_0, '0', analog_agc_xx_0, '0']
- [parse_telecmd, pdu_out, pdu_pdu_to_tagged_stream_2, pdus]
- [pdu_pdu_to_tagged_stream_2, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_2, '0', blocks_tag_debug_1, '0']
- [pdu_tagged_stream_to_pdu_0_0, pdus, virtual_sink_1, '0']
- [virtual_source_0, '0', digital_crc_check_0, in]
- [virtual_source_4, '0', digital_correlate_access_code_xx_ts_0, '0']
- [virtual_source_5, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
